# Keil uVision project name.uvproj, settings and files
target Name project (MCS-51)
  device: ML51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: name +hex
  c flags: Optimize=7 SizeSpeed=1
  c include: .\Library\Device\Include;.\Library\StdDriver\inc
  group Code
    ./: main.c
  group Startup
    ./Library/Startup/Keil/: STARTUP.A51
